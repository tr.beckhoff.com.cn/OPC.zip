{attribute 'qualified_only'}
VAR_GLOBAL
	b5:BOOL;
	{attribute 'OPC.UA.DA' := '1'}
	b6:BOOL;
END_VAR
