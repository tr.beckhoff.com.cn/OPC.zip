PROGRAM MAIN
VAR
	inc: INT;
	{attribute 'OPC.UA.DA' := '1'}
	mc1:INT;
END_VAR

Pro1();
inc:=inc+1;

END_PROGRAM
