TYPE CS1 :
STRUCT
	NAME:STRING;
	NO:UINT;
	MATH:REAL;
	LEG:REAL;
	SEC:REAL;
END_STRUCT
END_TYPE
